# Repository jgrip/open128 (continued)

## KiCad design Open128.kicad_pcb (continued)

Schematic: roms.sch, Open128

Parts:
C18, C32, C33, C34, C35, C36: 0.1 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E104MAR
C64: 0.01 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E103M
CN20: TA11; PinHeader_1x01_P2.54mm_Vertical
J4, J6: 128/256k; PinHeader_1x02_P2.54mm_Vertical
J7: SolderJumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
R36, R38: 10k; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4LCT52R103J
U8: 74LS08; DIP-14_W7.62mm; Mouser Part 595-SN74LS08N
U18: 2364; DIP-24_W15.24mm_Socket
U32, U33, U34: 23128; DIP-28_W15.24mm_Socket
U35: 318020-03; DIP-28_W15.24mm_Socket
U36: 23256; DIP-28_W15.24mm_Socket

Connections:
+5V: C18.2, C32.2, C33.2, C34.2, C35.2, C36.2, C64.1, R36.2, R38.1, U18.24 (VCC), U32.1 (NC), U32.28 (VCC), U33.1 (NC), U33.27 (A14/CS), U33.28 (VCC), U34.1 (NC), U34.28 (VCC), U35.1 (NC), U35.27 (A14/CS), U35.28 (VCC), U36.1 (NC), U36.28 (VCC); also elsewhere on the board
/Address Multiplexing/A0: U32.10 (A0), U33.10 (A0), U34.10 (A0), U35.10 (A0), U36.10 (A0); also elsewhere on the board
/Address Multiplexing/A1: U32.9 (A1), U33.9 (A1), U34.9 (A1), U35.9 (A1), U36.9 (A1); also elsewhere on the board
/Address Multiplexing/A2: U32.8 (A2), U33.8 (A2), U34.8 (A2), U35.8 (A2), U36.8 (A2); also elsewhere on the board
/Address Multiplexing/A3: U32.7 (A3), U33.7 (A3), U34.7 (A3), U35.7 (A3), U36.7 (A3); also elsewhere on the board
/Address Multiplexing/A4: U32.6 (A4), U33.6 (A4), U34.6 (A4), U35.6 (A4), U36.6 (A4); also elsewhere on the board
/Address Multiplexing/A5: U32.5 (A5), U33.5 (A5), U34.5 (A5), U35.5 (A5), U36.5 (A5); also elsewhere on the board
/Address Multiplexing/A6: U32.4 (A6), U33.4 (A6), U34.4 (A6), U35.4 (A6), U36.4 (A6); also elsewhere on the board
/Address Multiplexing/A7: U32.3 (A7), U33.3 (A7), U34.3 (A7), U35.3 (A7), U36.3 (A7); also elsewhere on the board
/Address Multiplexing/A8: U32.25 (A8), U33.25 (A8), U34.25 (A8), U35.25 (A8), U36.25 (A8); also elsewhere on the board
/Address Multiplexing/A9: U32.24 (A9), U33.24 (A9), U34.24 (A9), U35.24 (A9), U36.24 (A9); also elsewhere on the board
/Address Multiplexing/A10: U32.21 (A10), U33.21 (A10), U34.21 (A10), U35.21 (A10), U36.21 (A10); also elsewhere on the board
/Address Multiplexing/A11: U32.23 (A11), U33.23 (A11), U34.23 (A11), U35.23 (A11), U36.23 (A11); also elsewhere on the board
/Address Multiplexing/A12: U33.2 (A12), U34.2 (A12), U36.2 (A12); also elsewhere on the board
/Address Multiplexing/A13: U8.12, U33.26 (A13), U34.26 (A13), U35.26 (A13), U36.26 (A13); also elsewhere on the board
/Address Multiplexing/A14: U36.27 (A14/CS); also elsewhere on the board
/Address Multiplexing/A15: J4.1 (A); also elsewhere on the board
/Address Multiplexing/SA0: U18.8 (A0); also elsewhere on the board
/Address Multiplexing/SA1: U18.7 (A1); also elsewhere on the board
/Address Multiplexing/SA2: U18.6 (A2); also elsewhere on the board
/Address Multiplexing/SA3: U18.5 (A3); also elsewhere on the board
/Address Multiplexing/SA4: U18.4 (A4); also elsewhere on the board
/Address Multiplexing/SA5: U18.3 (A5); also elsewhere on the board
/Address Multiplexing/SA6: U18.2 (A6); also elsewhere on the board
/Address Multiplexing/SA7: U18.1 (A7); also elsewhere on the board
/Address Multiplexing/TA8: U18.23 (A8); also elsewhere on the board
/Address Multiplexing/TA9: U18.22 (A9); also elsewhere on the board
/Address Multiplexing/TA10: U18.19 (A10); also elsewhere on the board
/Address Multiplexing/TA11: CN20.1, U18.18 (A11); also elsewhere on the board
/Address Multiplexing/TA12: U32.2 (A12), U35.2 (A12); also elsewhere on the board
/Address Multiplexing/TA14: U8.13; also elsewhere on the board
/CPU 8502/CAPLK: J7.3 (B); also elsewhere on the board
/CPU 8502/D0: U18.9 (D0), U32.11 (D0), U33.11 (D0), U34.11 (D0), U35.11 (D0), U36.11 (D0); also elsewhere on the board
/CPU 8502/D1: U18.10 (D1), U32.12 (D1), U33.12 (D1), U34.12 (D1), U35.12 (D1), U36.12 (D1); also elsewhere on the board
/CPU 8502/D2: U18.11 (D2), U32.13 (D2), U33.13 (D2), U34.13 (D2), U35.13 (D2), U36.13 (D2); also elsewhere on the board
/CPU 8502/D3: U18.13 (D3), U32.15 (D3), U33.15 (D3), U34.15 (D3), U35.15 (D3), U36.15 (D3); also elsewhere on the board
/CPU 8502/D4: U18.14 (D4), U32.16 (D4), U33.16 (D4), U34.16 (D4), U35.16 (D4), U36.16 (D4); also elsewhere on the board
/CPU 8502/D5: U18.15 (D5), U32.17 (D5), U33.17 (D5), U34.17 (D5), U35.17 (D5), U36.17 (D5); also elsewhere on the board
/CPU 8502/D6: U18.16 (D6), U32.18 (D6), U33.18 (D6), U34.18 (D6), U35.18 (D6), U36.18 (D6); also elsewhere on the board
/CPU 8502/D7: U18.17 (D7), U32.19 (D7), U33.19 (D7), U34.19 (D7), U35.19 (D7), U36.19 (D7); also elsewhere on the board
/I/O/128_64: J6.1 (A), J7.1 (A); also elsewhere on the board
GND: C18.1, C32.1, C33.1, C34.1, C35.1, C36.1, C64.2, U18.12 (GND), U32.14 (GND), U32.20 (~CE), U33.14 (GND), U33.20 (~CE), U34.14 (GND), U34.20 (~CE), U35.14 (GND), U35.20 (~CE), U36.14 (GND), U36.20 (~CE); also elsewhere on the board
unnamed: J4.2 (B), R36.1, U34.27 (A14/CS)
unnamed: J6.2 (B), R38.2, U32.27 (A14/CS)
unnamed: J7.2 (C), U18.21 (A12)
unnamed: U8.11, U32.26 (A13)
~CS_CHAROM: U18.20 (CS/~CS); also elsewhere on the board
~CS_FROM: U36.22 (~OE); also elsewhere on the board
~CS_ROM1: U32.22 (~OE); also elsewhere on the board
~CS_ROM2: U33.22 (~OE); also elsewhere on the board
~CS_ROM3: U34.22 (~OE); also elsewhere on the board
~CS_ROM4: U35.22 (~OE); also elsewhere on the board

Notes on the sheet:
C64 ROM BASIC / KERNAL
CHARACTER ROM
BASIC ROM LO [4000 - 7FFFF]
BASIC ROM HI [8000 - BFFFF]
KERNAL ROM [C000 - FFFF]
FUNCTION ROM Empty socket

Schematic: ram.sch, Open128

Parts:
C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53: 0.22 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E104MAR
C65, C67: 0.01 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E103M
C66: 0.01 µF; C_Axial_L5.1mm_D3.1mm_P12.50mm_Horizontal; Mouser Part 581-SA105E103M
R1, R29, R30: 68; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4DCT52R68R0F
RP6: 1k; R_Array_SIP9; Mouser Part 652-4609X-1LF-1K
U9: 74F32; DIP-14_W7.62mm; Mouser Part 595-SN74F32N
U38, U39, U40, U41, U42, U43, U44, U45, U46, U47, U48, U49, U50, U51, U52, U53: 4164; DIP-16_W7.62mm_Socket

Connections:
+5V: C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C65.1, C66.1, C67.1, RP6.1 (common), U38.8 (VDD), U39.8 (VDD), U40.8 (VDD), U41.8 (VDD), U42.8 (VDD), U43.8 (VDD), U44.8 (VDD), U45.8 (VDD), U46.8 (VDD), U47.8 (VDD), U48.8 (VDD), U49.8 (VDD), U50.8 (VDD), U51.8 (VDD), U52.8 (VDD), U53.8 (VDD); also elsewhere on the board
/Address Multiplexing/MA0: RP6.8 (R7), U38.5 (A0), U39.5 (A0), U40.5 (A0), U41.5 (A0), U42.5 (A0), U43.5 (A0), U44.5 (A0), U45.5 (A0), U46.5 (A0), U47.5 (A0), U48.5 (A0), U49.5 (A0), U50.5 (A0), U51.5 (A0), U52.5 (A0), U53.5 (A0); also elsewhere on the board
/Address Multiplexing/MA1: RP6.2 (R1), U38.7 (A1), U39.7 (A1), U40.7 (A1), U41.7 (A1), U42.7 (A1), U43.7 (A1), U44.7 (A1), U45.7 (A1), U46.7 (A1), U47.7 (A1), U48.7 (A1), U49.7 (A1), U50.7 (A1), U51.7 (A1), U52.7 (A1), U53.7 (A1); also elsewhere on the board
/Address Multiplexing/MA2: RP6.6 (R5), U38.6 (A2), U39.6 (A2), U40.6 (A2), U41.6 (A2), U42.6 (A2), U43.6 (A2), U44.6 (A2), U45.6 (A2), U46.6 (A2), U47.6 (A2), U48.6 (A2), U49.6 (A2), U50.6 (A2), U51.6 (A2), U52.6 (A2), U53.6 (A2); also elsewhere on the board
/Address Multiplexing/MA3: RP6.7 (R6), U38.12 (A3), U39.12 (A3), U40.12 (A3), U41.12 (A3), U42.12 (A3), U43.12 (A3), U44.12 (A3), U45.12 (A3), U46.12 (A3), U47.12 (A3), U48.12 (A3), U49.12 (A3), U50.12 (A3), U51.12 (A3), U52.12 (A3), U53.12 (A3); also elsewhere on the board
/Address Multiplexing/MA4: RP6.5 (R4), U38.11 (A4), U39.11 (A4), U40.11 (A4), U41.11 (A4), U42.11 (A4), U43.11 (A4), U44.11 (A4), U45.11 (A4), U46.11 (A4), U47.11 (A4), U48.11 (A4), U49.11 (A4), U50.11 (A4), U51.11 (A4), U52.11 (A4), U53.11 (A4); also elsewhere on the board
/Address Multiplexing/MA5: RP6.4 (R3), U38.10 (A5), U39.10 (A5), U40.10 (A5), U41.10 (A5), U42.10 (A5), U43.10 (A5), U44.10 (A5), U45.10 (A5), U46.10 (A5), U47.10 (A5), U48.10 (A5), U49.10 (A5), U50.10 (A5), U51.10 (A5), U52.10 (A5), U53.10 (A5); also elsewhere on the board
/Address Multiplexing/MA6: RP6.9 (R8), U38.13 (A6), U39.13 (A6), U40.13 (A6), U41.13 (A6), U42.13 (A6), U43.13 (A6), U44.13 (A6), U45.13 (A6), U46.13 (A6), U47.13 (A6), U48.13 (A6), U49.13 (A6), U50.13 (A6), U51.13 (A6), U52.13 (A6), U53.13 (A6); also elsewhere on the board
/Address Multiplexing/MA7: RP6.3 (R2), U38.9 (A7), U39.9 (A7), U40.9 (A7), U41.9 (A7), U42.9 (A7), U43.9 (A7), U44.9 (A7), U45.9 (A7), U46.9 (A7), U47.9 (A7), U48.9 (A7), U49.9 (A7), U50.9 (A7), U51.9 (A7), U52.9 (A7), U53.9 (A7); also elsewhere on the board
/Address Multiplexing/~RAS: R1.2; also elsewhere on the board
/CPU 8502/D0: U38.2 (D), U38.14 (Q), U46.2 (D), U46.14 (Q); also elsewhere on the board
/CPU 8502/D1: U39.2 (D), U39.14 (Q), U47.2 (D), U47.14 (Q); also elsewhere on the board
/CPU 8502/D2: U40.2 (D), U40.14 (Q), U48.2 (D), U48.14 (Q); also elsewhere on the board
/CPU 8502/D3: U41.2 (D), U41.14 (Q), U49.2 (D), U49.14 (Q); also elsewhere on the board
/CPU 8502/D4: U42.2 (D), U42.14 (Q), U50.2 (D), U50.14 (Q); also elsewhere on the board
/CPU 8502/D5: U43.2 (D), U43.14 (Q), U51.2 (D), U51.14 (Q); also elsewhere on the board
/CPU 8502/D6: U44.2 (D), U44.14 (Q), U52.2 (D), U52.14 (Q); also elsewhere on the board
/CPU 8502/D7: U45.2 (D), U45.14 (Q), U53.2 (D), U53.14 (Q); also elsewhere on the board
/DRAM/~CAS: U9.10, U9.12; also elsewhere on the board
/DRAM/~DWE: U38.3 (~W), U39.3 (~W), U40.3 (~W), U41.3 (~W), U42.3 (~W), U43.3 (~W), U44.3 (~W), U45.3 (~W), U46.3 (~W), U47.3 (~W), U48.3 (~W), U49.3 (~W), U50.3 (~W), U51.3 (~W), U52.3 (~W), U53.3 (~W); also elsewhere on the board
/DRAM/~GCAS0: U9.9; also elsewhere on the board
/DRAM/~GCAS1: U9.13; also elsewhere on the board
GND: C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C65.2, C66.2, C67.2, U38.16 (VSS), U39.16 (VSS), U40.16 (VSS), U41.16 (VSS), U42.16 (VSS), U43.16 (VSS), U44.16 (VSS), U45.16 (VSS), U46.16 (VSS), U47.16 (VSS), U48.16 (VSS), U49.16 (VSS), U50.16 (VSS), U51.16 (VSS), U52.16 (VSS), U53.16 (VSS); also elsewhere on the board
unnamed: R1.1, U38.4 (~RAS), U39.4 (~RAS), U40.4 (~RAS), U41.4 (~RAS), U42.4 (~RAS), U43.4 (~RAS), U44.4 (~RAS), U45.4 (~RAS), U46.4 (~RAS), U47.4 (~RAS), U48.4 (~RAS), U49.4 (~RAS), U50.4 (~RAS), U51.4 (~RAS), U52.4 (~RAS), U53.4 (~RAS)
unnamed: R29.1, U38.15 (~CAS), U39.15 (~CAS), U40.15 (~CAS), U41.15 (~CAS), U42.15 (~CAS), U43.15 (~CAS), U44.15 (~CAS), U45.15 (~CAS)
unnamed: R29.2, U9.8
unnamed: R30.1, U46.15 (~CAS), U47.15 (~CAS), U48.15 (~CAS), U49.15 (~CAS), U50.15 (~CAS), U51.15 (~CAS), U52.15 (~CAS), U53.15 (~CAS)
unnamed: R30.2, U9.11

Schematic: address-multiplex.sch, Open128

Parts:
C14, C15, C17, C26, C55: 0.1 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E104MAR
C121: 0.01 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E104MAR
RP3, RP4: 33; R_Array_SIP8; Mouser Part 652-4608X-2LF-33
RP8: 3.3k; R_Array_SIP10; Mouser Part 652-4610X-1LF-3.3K
RP9, RP10: 10k; R_Array_SIP10; Mouser Part 652-4610X-1LF-10K
U14, U15, U26: 74LS257; DIP-16_W7.62mm; Mouser Part 595-SN74LS257BN
U17: 74LS373; DIP-20_W7.62mm; Mouser Part 595-SN74LS373N
U55: 74LS245; DIP-20_W7.62mm; Mouser Part 595-SN74LS245N
U62: 74LS244; DIP-20_W7.62mm; Mouser Part 595-SN74LS244N

Connections:
+5V: C14.2, C15.2, C17.2, C26.2, C55.2, C121.2, RP8.1 (common), RP9.1 (common), RP10.1 (common), U14.16 (VCC), U15.16 (VCC), U17.20 (VCC), U26.16 (VCC), U55.20 (VCC), U62.20 (VCC); also elsewhere on the board
/AEC: U17.1 (OE), U26.15 (OE); also elsewhere on the board
/Address Multiplexing/A0: RP9.10 (R9), U15.13 (I1c), U55.3 (A1); also elsewhere on the board
/Address Multiplexing/A1: RP9.9 (R8), U15.10 (I1d), U55.5 (A3); also elsewhere on the board
/Address Multiplexing/A2: RP9.8 (R7), U15.6 (I1b), U55.7 (A5); also elsewhere on the board
/Address Multiplexing/A3: RP9.7 (R6), U15.3 (I1a), U55.9 (A7); also elsewhere on the board
/Address Multiplexing/A4: RP9.6 (R5), U14.13 (I1c), U55.8 (A6); also elsewhere on the board
/Address Multiplexing/A5: RP9.5 (R4), U14.10 (I1d), U55.6 (A4); also elsewhere on the board
/Address Multiplexing/A6: RP9.4 (R3), U14.6 (I1b), U55.4 (A2); also elsewhere on the board
/Address Multiplexing/A7: RP9.3 (R2), U14.3 (I1a), U55.2 (A0); also elsewhere on the board
/Address Multiplexing/A8: RP10.2 (R1), U62.9 (O0b); also elsewhere on the board
/Address Multiplexing/A9: RP10.3 (R2), U62.12 (O3a); also elsewhere on the board
/Address Multiplexing/A10: RP10.4 (R3), U62.7 (O1b); also elsewhere on the board
/Address Multiplexing/A11: RP10.5 (R4), U62.14 (O2a); also elsewhere on the board
/Address Multiplexing/A12: RP10.6 (R5), U62.5 (O2b); also elsewhere on the board
/Address Multiplexing/A13: RP10.7 (R6), U62.16 (O1a); also elsewhere on the board
/Address Multiplexing/A14: RP10.8 (R7), U62.3 (O3b); also elsewhere on the board
/Address Multiplexing/A15: RP10.9 (R8), U62.18 (O0a); also elsewhere on the board
/Address Multiplexing/MA0: RP4.4 (R2); also elsewhere on the board
/Address Multiplexing/MA1: RP4.8 (R4); also elsewhere on the board
/Address Multiplexing/MA2: RP4.6 (R3); also elsewhere on the board
/Address Multiplexing/MA3: RP4.2 (R1); also elsewhere on the board
/Address Multiplexing/MA4: RP3.6 (R3); also elsewhere on the board
/Address Multiplexing/MA5: RP3.8 (R4); also elsewhere on the board
/Address Multiplexing/MA6: RP3.4 (R2); also elsewhere on the board
/Address Multiplexing/MA7: RP3.2 (R1); also elsewhere on the board
/Address Multiplexing/MUX: U14.1 (S), U15.1 (S), U26.1 (S); also elsewhere on the board
/Address Multiplexing/SA0: U17.2 (O0), U55.17 (B1); also elsewhere on the board
/Address Multiplexing/SA1: U17.5 (O1), U55.15 (B3); also elsewhere on the board
/Address Multiplexing/SA2: U17.6 (O2), U55.13 (B5); also elsewhere on the board
/Address Multiplexing/SA3: U17.9 (O3), U55.11 (B7); also elsewhere on the board
/Address Multiplexing/SA4: U17.12 (O4), U55.12 (B6); also elsewhere on the board
/Address Multiplexing/SA5: U17.15 (O5), U55.14 (B4); also elsewhere on the board
/Address Multiplexing/SA6: U17.16 (O6), U55.16 (B2); also elsewhere on the board
/Address Multiplexing/SA7: U17.19 (O7), U55.18 (B0); also elsewhere on the board
/Address Multiplexing/TA8: U15.14 (I0c), U62.11 (I0b); also elsewhere on the board
/Address Multiplexing/TA9: U15.11 (I0d), U62.8 (I3a); also elsewhere on the board
/Address Multiplexing/TA10: U15.5 (I0b), U62.13 (I1b); also elsewhere on the board
/Address Multiplexing/TA11: U15.2 (I0a), U62.6 (I2a); also elsewhere on the board
/Address Multiplexing/TA12: RP8.5 (R4), U14.14 (I0c), U62.15 (I2b); also elsewhere on the board
/Address Multiplexing/TA13: RP8.4 (R3), U14.11 (I0d), U62.4 (I1a); also elsewhere on the board
/Address Multiplexing/TA14: RP8.3 (R2), U14.5 (I0b), U62.17 (I3b); also elsewhere on the board
/Address Multiplexing/TA15: RP8.2 (R1), U14.2 (I0a), U62.2 (I0a); also elsewhere on the board
/Address Multiplexing/VA6: U17.17 (D6), U26.3 (I1a); also elsewhere on the board
/Address Multiplexing/VA7: U17.18 (D7), U26.6 (I1b); also elsewhere on the board
/Address Multiplexing/VA14: U26.2 (I0a); also elsewhere on the board
/Address Multiplexing/VA15: U26.5 (I0b); also elsewhere on the board
/Address Multiplexing/VMA0: RP4.3 (R2), U15.12 (Zc), U17.3 (D0); also elsewhere on the board
/Address Multiplexing/VMA1: RP4.7 (R4), U15.9 (Zd), U17.4 (D1); also elsewhere on the board
/Address Multiplexing/VMA2: RP4.5 (R3), U15.7 (Zb), U17.7 (D2); also elsewhere on the board
/Address Multiplexing/VMA3: RP4.1 (R1), U15.4 (Za), U17.8 (D3); also elsewhere on the board
/Address Multiplexing/VMA4: RP3.5 (R3), U14.12 (Zc), U17.13 (D4); also elsewhere on the board
/Address Multiplexing/VMA5: RP3.7 (R4), U14.9 (Zd), U17.14 (D5); also elsewhere on the board
/Address Multiplexing/VMA6: RP3.3 (R2), U14.7 (Zb), U26.4 (Za)
/Address Multiplexing/VMA7: RP3.1 (R1), U14.4 (Za), U26.7 (Zb)
/Address Multiplexing/~AEC: U14.15 (OE), U15.15 (OE), U55.19 (CE); also elsewhere on the board
/Address Multiplexing/~RAS: U26.13 (I1c); also elsewhere on the board
/CPU 8502/DMA: U55.1 (A->B), U62.1 (OEa), U62.19 (OEb); also elsewhere on the board
GND: C14.1, C15.1, C17.1, C26.1, C55.1, C121.1, U14.8 (GND), U15.8 (GND), U17.10 (GND), U26.8 (GND), U26.10 (I1d), U26.11 (I0d), U26.14 (I0c), U55.10 (GND), U62.10 (GND); also elsewhere on the board
unnamed: U17.11 (LE), U26.12 (Zc)

Schematic: expansion.sch, Open128

Parts:
CN1: Expansion bus; EXPANSIONPORT
R43: 3.3k; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4LCT52R332J
RP5: 3.3k; R_Array_SIP8; Mouser Part 652-4608X-1LF-3.3K

Connections:
+5V: CN1.2, CN1.3, R43.1, RP5.1 (common); also elsewhere on the board
/Address Multiplexing/SA0: CN1.Y; also elsewhere on the board
/Address Multiplexing/SA1: CN1.X; also elsewhere on the board
/Address Multiplexing/SA2: CN1.W; also elsewhere on the board
/Address Multiplexing/SA3: CN1.V; also elsewhere on the board
/Address Multiplexing/SA4: CN1.U; also elsewhere on the board
/Address Multiplexing/SA5: CN1.T; also elsewhere on the board
/Address Multiplexing/SA6: CN1.S; also elsewhere on the board
/Address Multiplexing/SA7: CN1.R; also elsewhere on the board
/Address Multiplexing/TA8: CN1.P; also elsewhere on the board
/Address Multiplexing/TA9: CN1.N; also elsewhere on the board
/Address Multiplexing/TA10: CN1.M; also elsewhere on the board
/Address Multiplexing/TA11: CN1.L; also elsewhere on the board
/Address Multiplexing/TA12: CN1.K; also elsewhere on the board
/Address Multiplexing/TA13: CN1.J; also elsewhere on the board
/Address Multiplexing/TA14: CN1.H; also elsewhere on the board
/Address Multiplexing/TA15: CN1.F; also elsewhere on the board
/BA: CN1.12; also elsewhere on the board
/CPU 8502/D0: CN1.21; also elsewhere on the board
/CPU 8502/D1: CN1.20; also elsewhere on the board
/CPU 8502/D2: CN1.19; also elsewhere on the board
/CPU 8502/D3: CN1.18; also elsewhere on the board
/CPU 8502/D4: CN1.17; also elsewhere on the board
/CPU 8502/D5: CN1.16; also elsewhere on the board
/CPU 8502/D6: CN1.15; also elsewhere on the board
/CPU 8502/D7: CN1.14; also elsewhere on the board
/CPU 8502/DMA: CN1.13, R43.2; also elsewhere on the board
/CPU 8502/~NMI: CN1.D; also elsewhere on the board
/Clock/~ϕDOT: CN1.6; also elsewhere on the board
/Expansion Port/1MHZ: CN1.E; also elsewhere on the board
/Expansion Port/~EXROM: CN1.9, RP5.8 (R7); also elsewhere on the board
/Expansion Port/~GAME: CN1.8, RP5.7 (R6); also elsewhere on the board
/R~W: CN1.5; also elsewhere on the board
/~IRQ: CN1.4; also elsewhere on the board
GND: CN1.1, CN1.22, CN1.A, CN1.Z; also elsewhere on the board
~CS_IO1: CN1.7; also elsewhere on the board
~CS_IO2: CN1.10; also elsewhere on the board
~CS_ROMH: CN1.B; also elsewhere on the board
~CS_ROML: CN1.11; also elsewhere on the board
~RESET: CN1.C; also elsewhere on the board

Schematic: keyboard.sch, Open128

Parts:
C89: 51 pF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Mouser Part 581-SA102A510JAA
C90: 360 pF; C_Disc_D10.0mm_W2.5mm_P5.00mm
C114: 0.01 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E103M
CN5: Conn_01x25; DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_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
R9, R20: 10k; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4LCT52R103J
R21: 470k; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4LCT52R474J
R22: 47k; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4LCT52R473J
RP2: 1k; R_Array_SIP9; Mouser Part 652-4609X-1LF-1K
RP8: 3.3k; R_Array_SIP10; Mouser Part 652-4610X-1LF-3.3K
U16: 74LS14; DIP-14_W7.62mm; Mouser Part 595-SN74LS14N
U27: LM556; DIP-14_W7.62mm; Mouser Part 595-NA556N
U29, U37: 7406; DIP-14_W7.62mm; Mouser Part 595-SN74LS06N

Connections:
+5V: C114.1, CN5.4, R9.1, R20.1, R21.1, R22.1, RP2.1 (common), RP8.1 (common), U27.4 (R), U27.14 (VCC); also elsewhere on the board
/CPU 8502/CAPLK: CN5.25, RP8.10 (R9); also elsewhere on the board
/CPU 8502/~NMI: RP2.5 (R8), U29.4; also elsewhere on the board
/I/O/4080: RP8.9 (R8); also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_4080: CN5.24; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL0: CN5.13; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL1: CN5.19; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL2: CN5.18; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL3: CN5.17; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL4: CN5.16; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL5: CN5.15; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL6: CN5.14; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL7: CN5.20; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_GND: CN5.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_K0: CN5.21; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_K1: CN5.22; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_K2: CN5.23; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW0: CN5.12; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW1: CN5.11; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW2: CN5.10; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW3: CN5.5; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW4: CN5.8; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW5: CN5.7; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW6: CN5.6; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW7: CN5.9; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_RSTR: CN5.3; also elsewhere on the board
/I/O/Keyboard/RESTORE: R9.2, U16.9; also elsewhere on the board
GND: C90.1, C114.2, CN5.0 (PAD), U27.7 (GND); also elsewhere on the board
unnamed: C89.1, R20.2, U37.2
unnamed: C89.2, R21.2, U27.6 (TR)
unnamed: C90.2, R22.2, U27.1 (DIS), U27.2 (THR)
unnamed: U16.8, U37.1
unnamed: U27.5 (Q), U29.3

Schematic: controlports.sch, Open128

Parts:
C71: 0.1 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E104MAR
CN3: Port1 Male DB9; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset14.56mm_Ho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; Mouser Part 636-183-009-113R531
CN4: Port2 Male DB9; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset14.56mm_Ho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; Mouser Part 636-183-009-113R531
U2: 4066; DIP-14_W7.62mm; Mouser Part 595-CD74HCT4066E

Connections:
+5V: C71.1, CN3.7, CN4.7; also elsewhere on the board
/I/O/COL6: U2.6, U2.12; also elsewhere on the board
/I/O/COL7: U2.5, U2.13; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_FBTNA: CN3.6; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_FBTNB: CN4.6; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_JOYA0: CN3.1; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_JOYA1: CN3.2; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_JOYA2: CN3.3; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_JOYA3: CN3.4; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_JOYB0: CN4.1; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_JOYB1: CN4.2; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_JOYB2: CN4.3; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_JOYB3: CN4.4; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_POTAX: CN3.9; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_POTAY: CN3.5; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_POTBX: CN4.9; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/IN_POTBY: CN4.5; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/OUT_POTAX: U2.8; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/OUT_POTAY: U2.11; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/OUT_POTBX: U2.1; also elsewhere on the board
/I/O/Control Ports/Control Ports-EMI/OUT_POTBY: U2.4; also elsewhere on the board
/I/O/POTX: U2.2, U2.9; also elsewhere on the board
/I/O/POTY: U2.3, U2.10; also elsewhere on the board
GND: C71.2, CN3.0 (PAD), CN3.8, CN4.0 (PAD), CN4.8; also elsewhere on the board

Schematic: userport.sch, Open128

Parts:
C76: 0.1 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E104MAR
C78, C79: 1000 pF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 50V; Voltage Tolerance 10%; Mouser Part 581-SA101C102KAN
CN9: User Port; USERPORT
R44: 3.3k; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4LCT52R332J
RP1: 1k; R_Array_SIP8; Mouser Part 652-4608X-1LF-1K
RP5: 3.3k; R_Array_SIP8; Mouser Part 652-4608X-1LF-3.3K
U57: 7407; DIP-14_W7.62mm; Mouser Part 595-SN74LS07N

Connections:
9VAC1: C79.2, CN9.10; also elsewhere on the board
9VAC2: C78.2, CN9.11; also elsewhere on the board
+5V: C76.2, CN9.2, R44.1, RP1.1 (common), RP5.1 (common); also elsewhere on the board
/I/O/PB0: CN9.C; also elsewhere on the board
/I/O/PB1: CN9.D; also elsewhere on the board
/I/O/PB2: CN9.E; also elsewhere on the board
/I/O/PB3: CN9.F; also elsewhere on the board
/I/O/PB4: CN9.H; also elsewhere on the board
/I/O/PB5: CN9.J; also elsewhere on the board
/I/O/PB6: CN9.K; also elsewhere on the board
/I/O/PB7: CN9.L; also elsewhere on the board
/I/O/Serial Bus/ATN: CN9.9; also elsewhere on the board
/I/O/Serial Bus/CNT: CN9.4, RP5.5 (R4); also elsewhere on the board
/I/O/Serial Bus/SP: CN9.5, RP5.6 (R5); also elsewhere on the board
/I/O/Serial Bus/~EXTRES: CN9.3, RP1.6 (R5), U57.10; also elsewhere on the board
/I/O/Userport/CNT2: CN9.6, RP5.3 (R2); also elsewhere on the board
/I/O/Userport/PA2: CN9.M; also elsewhere on the board
/I/O/Userport/SP2: CN9.7, R44.2; also elsewhere on the board
/I/O/Userport/~FLAG2: CN9.B; also elsewhere on the board
/I/O/Userport/~PC2: CN9.8; also elsewhere on the board
GND: C76.1, C78.1, C79.1, CN9.1, CN9.12, CN9.A, CN9.N; also elsewhere on the board
~RESET: U57.11; also elsewhere on the board

Schematic: serialbus.sch, Open128

Parts:
CN6: DIN6 Male; Connector_DIN_Female_6Pin_3rows
CN7: 7 pin post; PinHeader_1x07_P2.54mm_Vertical
CR2, CR3, CR4, CR5, CR6, CR7, CR9, CR100: 1N914; D_DO-35_SOD27_P12.70mm_Horizontal; Mouser Part 512-1N914
FB7, FB8, FB9, FB10, FB11, FB12: Ferrite_Bead_Small; Ferrite_Bead_vertical; Mouser Part 81-BL02RN2R1M2B
R3: 1k; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4LCT52R102J
RP1: 1k; R_Array_SIP8; Mouser Part 652-4608X-1LF-1K
RP2: 1k; R_Array_SIP9; Mouser Part 652-4609X-1LF-1K
U8: 74LS08; DIP-14_W7.62mm; Mouser Part 595-SN74LS08N
U16: 74LS14; DIP-14_W7.62mm; Mouser Part 595-SN74LS14N
U30, U37: 7406; DIP-14_W7.62mm; Mouser Part 595-SN74LS06N
U58: 74LS03; DIP-14_W7.62mm; Mouser Part 595-SN74LS03N
U60: 7407; DIP-14_W7.62mm; Mouser Part 595-SN74LS07N

Connections:
+5V: CR5.1 (K), CR6.1 (K), CR7.1 (K), CR9.1 (K), R3.1, RP1.1 (common), RP2.1 (common); also elsewhere on the board
/I/O/128_64: U8.9; also elsewhere on the board
/I/O/Serial Bus/ATN: CN7.3, CR4.1 (K), CR5.2 (A), FB10.2, RP1.5 (R4), U30.6; also elsewhere on the board
/I/O/Serial Bus/ATNOUT: U30.5; also elsewhere on the board
/I/O/Serial Bus/CLK: CN7.4, CR3.1 (K), CR6.2 (A), FB9.2, RP1.4 (R3), U30.4; also elsewhere on the board
/I/O/Serial Bus/CLKOUT: U30.3; also elsewhere on the board
/I/O/Serial Bus/CNT: U37.13, U58.3; also elsewhere on the board
/I/O/Serial Bus/DATA: CN7.5, CR2.1 (K), CR7.2 (A), FB8.2, RP1.3 (R2), U16.1, U30.2, U60.8; also elsewhere on the board
/I/O/Serial Bus/DATAOUT: U30.1; also elsewhere on the board
/I/O/Serial Bus/SP: U37.3, U58.8; also elsewhere on the board
/I/O/Serial Bus/~EXTRES: FB11.2; also elsewhere on the board
/I/O/Serial Bus/~SRQIN: CN7.1, CR9.2 (A), CR100.1 (K), FB7.2, R3.2, U16.3, U60.6; also elsewhere on the board
/I/O/~DRESET: CN7.7; also elsewhere on the board
/Memory Management/FSDIR: U16.13, U58.4, U58.13; also elsewhere on the board
GND: CN6.SH (Shield), CN7.2, CR2.2 (A), CR3.2 (A), CR4.2 (A), CR100.2 (A), FB7.3 (GND), FB8.3 (GND), FB9.3 (GND), FB10.3 (GND), FB11.3 (GND), FB12.2, FB12.3 (GND); also elsewhere on the board
unnamed: CN6.1, FB7.1
unnamed: CN6.2, FB12.1
unnamed: CN6.3, FB10.1
unnamed: CN6.4, FB9.1
unnamed: CN6.5, FB8.1
unnamed: CN6.6, FB11.1
unnamed: RP2.2 (R8), U58.6, U60.5
unnamed: RP2.3 (R8), U37.12, U58.5
unnamed: RP2.4 (R8), U58.11, U60.9
unnamed: RP2.6 (R8), U37.4, U58.12
unnamed: U16.2, U58.9
unnamed: U16.4, U58.2
unnamed: U8.10, U16.12
unnamed: U8.8, U58.1, U58.10

Notes on the sheet:
Only C128D

Schematic: casetteinterface.sch, Open128

Parts:
C70: 0.1 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E104MAR
C72, C73, C75: 470 pF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Mouser Part 581-SA101A471JAR
CN2: Cassette; CASSETTEPORT
CR1: 6.8v; D_DO-35_SOD27_P12.70mm_Horizontal; Mouser Part 771-BZX79-B6V8,143
FB1, FB2, FB3, FB4, FB5, FB6: Ferrite_Bead_Small; Ferrite_Bead_vertical; Mouser Part 81-BL02RN2R1M2B
Q3: 2SD880; TO-220-3_Horizontal_TabDown; Mouser Part 512-KSD880YTU
R4: 100; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4DCT52A1000F
R5: 470; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4DCT52R4700F
RP5: 3.3k; R_Array_SIP8; Mouser Part 652-4608X-1LF-3.3K
U30: 7406; DIP-14_W7.62mm; Mouser Part 595-SN74LS06N

Connections:
+5V: C70.2, FB1.2, RP5.1 (common); also elsewhere on the board
+9V: Q3.2 (C), R5.2; also elsewhere on the board
/CPU 8502/P3: R4.2; also elsewhere on the board
/CPU 8502/P4: C72.2, FB3.2, RP5.2 (R1); also elsewhere on the board
/CPU 8502/P5: U30.13; also elsewhere on the board
/I/O/Casette Interface/CASS3: FB5.2, Q3.3 (E)
/I/O/Casette Interface/CASS5: C73.2, FB4.2, R4.1
/I/O/Casette Interface/CCN1: CN2.1, CN2.A, FB2.1
/I/O/Casette Interface/CCN2: CN2.2, CN2.B, FB1.1
/I/O/Casette Interface/CCN3: CN2.3, CN2.C, FB5.1
/I/O/Casette Interface/CCN4: CN2.4, CN2.D, FB6.1
/I/O/Casette Interface/CCN5: CN2.5, CN2.E, FB4.1
/I/O/Casette Interface/CCN6: CN2.6, CN2.F, FB3.1
/I/O/Casette Interface/READ: C75.2, FB6.2; also elsewhere on the board
GND: C70.1, C72.1, C73.1, C75.1, CR1.2 (A), FB1.3 (GND), FB2.2, FB2.3 (GND), FB3.3 (GND), FB4.3 (GND), FB5.3 (GND), FB6.3 (GND); also elsewhere on the board
unnamed: CR1.1 (K), Q3.1 (B), R5.1, U30.12

Schematic: rf-modulator.sch, Open128

Parts:
C93: 0.1 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E104MAR
C94: 0.22 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Mouser Part 581-SA115E224MAR
C120: 0.01 µF; C_Disc_D10.0mm_W2.5mm_P5.00mm; Voltage Rating 25V; Voltage Tolerance +80% -20%; Mouser Part 581-SA105E103M
CN8: 8 pin DIN; Connector_DIN_Female_8Pin_3rows
EMI39: 270 pF; EMI-Filter; Mouser Part 81-DSS1NB32A271Q91A
EMI40, EMI41, EMI42: 100 pF; EMI-Filter; Mouser Part 81-DSS1NB32A101Q91A
FB13, FB14, FB15, FB19, FB20: Ferrite_Bead_Small; Ferrite_Bead_vertical; Mouser Part 81-BL02RN2R1M2B
L3: 2.2 µH; L_Axial_L9.5mm_D4.0mm_P12.70mm_Horizontal_Fastron_SMCC; Mouser Part 871-B78108S1222K
M1: RF_Modulator; RF_modulator
R25: 100k; R_Axial_DIN0309_L9.0mm_D2.5mm_P12.70mm_Horizontal; Mouser Part 660-MF1/4LCT52R104J

Connections:
+5V: FB13.2, L3.1; also elsewhere on the board
/Sound/AUDIO_OUT: EMI39.1, FB14.2; also elsewhere on the board
/Sound/EXT_AUDIO: C93.1; also elsewhere on the board
/VIC/RF Modulator and AV connectors/CHROMA: FB20.1; also elsewhere on the board
/VIC/RF Modulator and AV connectors/SYNC_LUM: FB19.1; also elsewhere on the board
GND: C94.1, C120.2, CN8.2, CN8.SH (Shield), EMI39.2, EMI40.2, EMI41.2, EMI42.2, FB13.3 (GND), FB14.3 (GND), FB15.3 (GND), FB19.3 (GND), FB20.3 (GND), M1.3 (GND), R25.1; also elsewhere on the board
unnamed: C93.2, FB15.2, R25.2
unnamed: C94.2, C120.1, L3.2, M1.1 (V+)
unnamed: CN8.1, EMI41.3
unnamed: CN8.3, FB14.1
unnamed: CN8.4, EMI40.3
unnamed: CN8.5, FB15.1
unnamed: CN8.6, EMI42.3
unnamed: CN8.8, FB13.1
unnamed: EMI39.3, M1.8 (AUDIO)
unnamed: EMI40.1, M1.5 (COMP)
unnamed: EMI41.1, M1.6 (SYNC/LUM_OUT)
unnamed: EMI42.1, M1.7 (CHROMA_OUT)
unnamed: FB19.2, M1.2 (SYNC/LUM)
unnamed: FB20.2, M1.4 (CHROMA)

Schematic: keyboard-emi.sch, Open128

Parts:
EMI16, EMI17, EMI18, EMI19, EMI20, EMI21, EMI22, EMI23, EMI24, EMI25, EMI26, EMI27, EMI28, EMI29, EMI30, EMI31, EMI32, EMI33, EMI34, EMI35, EMI37, EMI38: 100 pF; EMI-Filter; Mouser Part 81-DSS1NB32A101Q91A

Connections:
/I/O/4080: EMI16.3; also elsewhere on the board
/I/O/COL0: EMI20.3; also elsewhere on the board
/I/O/COL1: EMI21.3; also elsewhere on the board
/I/O/COL2: EMI22.3; also elsewhere on the board
/I/O/COL3: EMI23.3; also elsewhere on the board
/I/O/COL4: EMI24.3; also elsewhere on the board
/I/O/COL5: EMI25.3; also elsewhere on the board
/I/O/COL6: EMI26.3; also elsewhere on the board
/I/O/COL7: EMI27.3; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_4080: EMI16.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL0: EMI20.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL1: EMI21.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL2: EMI22.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL3: EMI23.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL4: EMI24.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL5: EMI25.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL6: EMI26.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_COL7: EMI27.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_GND: EMI38.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_K0: EMI17.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_K1: EMI18.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_K2: EMI19.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW0: EMI28.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW1: EMI29.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW2: EMI30.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW3: EMI31.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW4: EMI32.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW5: EMI33.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW6: EMI34.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_ROW7: EMI35.1; also elsewhere on the board
/I/O/Keyboard/Key-EMI/IN_RSTR: EMI37.1; also elsewhere on the board
/I/O/Keyboard/RESTORE: EMI37.3; also elsewhere on the board
/I/O/ROW0: EMI28.3; also elsewhere on the board
/I/O/ROW1: EMI29.3; also elsewhere on the board
/I/O/ROW2: EMI30.3; also elsewhere on the board
/I/O/ROW3: EMI31.3; also elsewhere on the board
/I/O/ROW5: EMI33.3; also elsewhere on the board
/I/O/ROW6: EMI34.3; also elsewhere on the board
/I/O/ROW7: EMI35.3; also elsewhere on the board
/VIC/K0: EMI17.3; also elsewhere on the board
/VIC/K1: EMI18.3; also elsewhere on the board
/VIC/K2: EMI19.3; also elsewhere on the board
/VIC/~LIGHTPEN: EMI32.3; also elsewhere on the board
GND: EMI16.2, EMI17.2, EMI18.2, EMI19.2, EMI20.2, EMI21.2, EMI22.2, EMI23.2, EMI24.2, EMI25.2, EMI26.2, EMI27.2, EMI28.2, EMI29.2, EMI30.2, EMI31.2, EMI32.2, EMI33.2, EMI34.2, EMI35.2, EMI37.2, EMI38.2, EMI38.3; also elsewhere on the board

Notices in the files:
Open128.kicad_pcb:
https://creativecommons.org/licenses/by-sa/4.0
CC BY-SA 4.0
address-multiplex.sch:
Licensed under CC BY-SA 4.0
